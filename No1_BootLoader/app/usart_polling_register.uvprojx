# Keil uVision project usart_polling_register.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_register +hex
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf.exe  --bin  --output=app.bin  Objects\led_register.axf
  AfterMake: D:\Keil5\ARM\ARMCC\bin\fromelf.exe  --text  -a -c  --output=app.dis  Objects\led_register.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\Hardware\LED;.\Hardware\KEY;.\Hardware\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0xc800
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\led_register.sct
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c delay.c
  group Hardware\LED
    ./Hardware/LED/: led.c
  group Hardware\KEY
    ./Hardware/KEY/: key.c
  group Hardware\USART
    ./Hardware/USART/: usart.c
